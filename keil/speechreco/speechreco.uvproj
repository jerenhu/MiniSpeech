# Keil uVision project speechreco.uvproj, settings and files
target speechreco (ARM-ADS)
  device: N575F145 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: ADC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: 'C:\Users\yanhui\myData\speech\Library\Device\Nuvoton\N575\Source';'C:\Users\yanhui\myData\speech\Library\Device\Nuvoton\N575\Include';'C:\Users\yanhui\myData\speech\Library\CMSIS\Include';'C:\Users\yanhui\myData\speech\Library\Framework\inc';'C:\Users\yanhui\myData\speech\Library\StdDriver\inc';'C:\Users\yanhui\myData\speech\Library\Storage\inc';'C:\Users\yanhui\myData\speech\Library\IO\inc'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_n575_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_N575_Keil.s
    ../Library/Device/Nuvoton/N575/Source/: system_N575.c
  group User
    ../: main.c
  group Library
    ../Library/StdDriver/src/: uart.c sys.c spi.c retarget.c pdma.c fmc.c clk.c gpio.c adc.c timer.c capsense.c
    ../Library/IO/src/: Keypad.c
  group vr
    ../: recordctrl.h recordctrl.c vadctrl.c vadctrl.h flash.c flash.h
